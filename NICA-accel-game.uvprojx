# Keil uVision project NICA-accel-game.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NICA-accel-game +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\lib\App;.\lib\HW;.\lib\CMSIS;.\lib\SPL;.\lib\assets;.\lib\LCD_RA8876_FT5316;.\lib\Square-GUI;.\lib\GUI
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./lib/App/: main.c
  group HW
    ./lib/HW/: CPU.c CPU.h EXTI.c EXTI.h GPIO.c GPIO.h I2C.c I2C.h SPI.c SPI.h Timer.c Timer.h
  group GUI
    ./lib/GUI/: gui_impl.c gui_impl.h SGUI_dataTransfer.c game_linAccel.c game_linAccel.h game_ions.c game_ions.h swipe.c swipe.h
  group CMSIS
    ./lib/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx_conf.h
  group SPL
    ./lib/SPL/: misc.c misc.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h
  group assets
    ./lib/assets/: circle_booster_8bpp.c detector_8bpp.c ions_source_8bpp.c linear_booster_8bpp.c jinr_building_main_8bpp.c nica_logo_8bpp.c
  group LCD
    ./lib/LCD_RA8876_FT5316/: FT5316.c FT5316.h LCD_api.c LCD_api.h RA8876.c RA8876.h
  group SGUI
    ./lib/Square-GUI/: SGUI.c SGUI.h SGUI_button.c SGUI_button.h SGUI_canvas.c SGUI_canvas.h SGUI_config.h SGUI_dataTransfer.h SGUI_label.c SGUI_label.h SGUI_page.c SGUI_page.h SGUI_primitives.c SGUI_primitives.h SGUI_system.c SGUI_system.h SGUI_picture.c SGUI_picture.h SGUI_string.c SGUI_string.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
